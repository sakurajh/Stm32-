# Keil uVision project xj.uvprojx, settings and files
target xj (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: zcd +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --gnu
  c include: ..\core;..\drive;..\fwlib\inc;..\user;..\user;..\core;..\..\..\【正点原子】Nano STM32F103 V2开发板资料（新资料）\4，程序源码\2，标准例程-HAL库函数版本\2，标准例程-HAL库函数版本\实验0-1 Template工程模板-新建工程章节使用\HALLIB\STM32F1xx_HAL_Driver\Inc;..\drive
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group core
    ../core/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group fwlib
    ../fwlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group drive
    ../drive/: motor.c track.c Delay.c OLED.c OLED_Font.h OLED.h Menu.c
    ./: Buzzer.c Buzzer.h
  group user
    ../user/: main.c stm32f10x_it.c
